# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: CMSDK_CM7_DP_VHT ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.4, Board Support:Common 2.0.0, Device:Startup 1.1.0
